options:
  parameters:
    generate_options: qt_gui
    id: SimpleFM_RX
    output_language: python
    title: Simple FM Receiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: frequency_rx
  id: variable
  parameters:
    value: (frequency_rx_input)*1000000
  states: {}
- name: frequency_rx_input
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Receive Frequency
    orient: Qt.Horizontal
    start: '80'
    step: '0.1'
    stop: '150'
    value: '104.700'
  states: {}
- name: lpf_decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: lpf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: simple_fm_receiver@1
    label: LPF_Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '100'
    value: '28'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: simple_fm_receiver@0
    label: 'RF Gain:'
    orient: Qt.Horizontal
    rangeType: int
    start: '10'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    label: 'Volume:'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '2'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/lpf_decimation
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /Users/sechen/Documents/GNURadio-Experiments/Samples/FM_Broadcast.wav
    samp_rate: audio_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: lpf_decimation
    gain: lpf_gain
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"soapy=0,driver=remote,remote=sdr-pi.local:55132,remote:driver=rtlsdr"'
    bb_gain0: '20'
    freq0: frequency_rx
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/lpf_decimation
    fc: frequency_rx
    fftsize: '1024'
    gui_hint: simple_fm_receiver@2
    name: Demodulated Output
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/lpf_decimation
    fc: frequency_rx
    fftsize: '1024'
    gui_hint: simple_fm_receiver@1
    name: Raw Output
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequency_rx
    fftsize: '1024'
    gui_hint: simple_fm_receiver@0
    name: Source RF
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int((samp_rate/lpf_decimation)/1e3)
    fbw: '0.4'
    interp: int(audio_rate/1e3)
    taps: ''
    type: fff
  states: {}
- name: simple_fm_receiver
  id: qtgui_tab_widget
  parameters:
    gui_hint: '[2,0,1,1]'
    label0: Source
    label1: Low Pass Filter
    label2: Demodulated
    num_tabs: '3'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1

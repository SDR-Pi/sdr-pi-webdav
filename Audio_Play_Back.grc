options:
  parameters:
    generate_options: qt_gui
    id: Audio_Play_Back
    output_language: python
    title: Audio_Play_Back
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/sechen/Documents/GNURadio-Experiments/Samples/FM_Broadcast.wav
    repeat: 'True'
  states: {}

connections:
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1

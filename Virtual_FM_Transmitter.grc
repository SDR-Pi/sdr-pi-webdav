options:
  parameters:
    description: Both the Transmit and Receive pathways for a WBFM (Broadcast) FM Transeiver.
    generate_options: qt_gui
    id: Virtual_FM_Transmitter
    output_language: python
    title: Virtual FM Transceiver
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: virtual_fm_transceiver@1:(1,0,1,1)
    label: Audio Gain
    orient: Qt.Vertical
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.9'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: frequency_rx
  id: variable
  parameters:
    value: (frequency_rx_input)*1e6
  states: {}
- name: frequency_rx_input
  id: variable_qtgui_range
  parameters:
    gui_hint: virtual_fm_transceiver@3:(0,0,1,1)
    label: Receive Frequency
    orient: Qt.Horizontal
    start: '80'
    step: '0.1'
    stop: '150'
    value: '104.700'
  states: {}
- name: frequency_tx
  id: variable
  parameters:
    value: (frequency_rx_input)*1e6
  states: {}
- name: frequency_tx_input
  id: variable_qtgui_range
  parameters:
    gui_hint: virtual_fm_transceiver@1:(0,0,1,1)
    label: Transmit Frequency
    orient: Qt.Vertical
    start: '80'
    step: '0.1'
    stop: '150'
    value: '104.700'
  states: {}
- name: lpf_decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: lpf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: simple_fm_receiver@1
    label: LPF_Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: reduce_channelised_power
  id: variable_qtgui_range
  parameters:
    gui_hint: virtual_fm_transceiver@2:(2,0,1,1)
    label: Adjust Channelised Power
    orient: Qt.Vertical
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: simple_fm_receiver@0
    label: 'RF Gain:'
    orient: Qt.Horizontal
    rangeType: int
    start: '-10'
    step: '1'
    stop: '70'
    value: '10'
  states: {}
- name: rf_noise
  id: variable_qtgui_range
  parameters:
    gui_hint: virtual_fm_transceiver@2:(0,0,1,1)
    label: Transmit Noise
    orient: Qt.Vertical
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: source_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: virtual_fm_transceiver@0
    label: 'Source:'
    label0: 'Microphone:'
    label1: 'Tone:'
    label2: 'Pre-recorded Wav:'
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: tone_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: virtual_fm_transceiver@0
    label: Frequency For Constant Tone (Hz)
    orient: Qt.Vertical
    rangeType: int
    start: '0'
    step: '10'
    stop: '3000'
    value: '500'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: virtual_fm_transceiver@3:(1,0,1,1)
    label: 'Volume:'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tone_frequency
    offset: '0'
    phase: '0'
    samp_rate: int(audio_rate)
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: int(audio_rate)
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/lpf_decimation
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(audio_rate)
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: int(audio_rate)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: int(audio_rate)
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    samp_rate: int(audio_rate)
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 5e3
    low_cutoff_freq: '300'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: reduce_channelised_power
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source_select
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/sechen/Documents/GNURadio-Experiments/Samples/FM_Broadcast.wav
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: rf_noise
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: lpf_decimation
    gain: lpf_gain
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/lpf_decimation
    fc: frequency_rx
    fftsize: '1024'
    gui_hint: simple_fm_receiver@2
    name: Demodulated Output
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/lpf_decimation
    fc: frequency_rx
    fftsize: '1024'
    gui_hint: simple_fm_receiver@1
    name: Raw Output
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequency_rx
    fftsize: '1024'
    gui_hint: simple_fm_receiver@0
    name: Source RF
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: int(audio_rate)
    fc: frequency_tx
    fftsize: '1024'
    gui_hint: virtual_fm_transceiver@1:(2,0,1,1)
    name: Transmitter Audio Analysis
    plotfreq: 'False'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequency_tx
    fftsize: '1024'
    gui_hint: virtual_fm_transceiver@2:(1,0,1,1)
    name: RF Spectrum
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int((samp_rate/lpf_decimation)/1e3)
    fbw: '0.4'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: ''
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: ''
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: simple_fm_receiver
  id: qtgui_tab_widget
  parameters:
    gui_hint: virtual_fm_transceiver@3:(2,0,1,1)
    label0: Source
    label1: Low Pass Filter
    label2: Demodulated
    num_tabs: '3'
  states: {}
- name: virtual_fm_transceiver
  id: qtgui_tab_widget
  parameters:
    label0: Audio Source
    label1: Transmitter
    label2: RF Spectrum
    label3: Receiver
    num_tabs: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Receive-Virtual-Sink
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Transmit-Virtual-Sink
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Receive-Virtual-Sink
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Transmit-Virtual-Sink
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_selector_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_tx_0, '0', virtual_sink_1, '0']
- [audio_source_0, '0', blocks_selector_0, '0']
- [audio_source_0_0, '0', blocks_multiply_const_vxx_2, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_0, '0', analog_wfm_tx_0, '0']
- [blocks_add_xx_0, '0', audio_sink_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_1, '0']
- [blocks_add_xx_1, '0', blocks_selector_0, '2']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_1, '1']
- [blocks_selector_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_1, '0']
- [channels_channel_model_0, '0', rational_resampler_xxx_1_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [rational_resampler_xxx_1_0, '0', qtgui_sink_x_2, '0']
- [rational_resampler_xxx_1_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', qtgui_sink_x_0_0_0, '0']
- [virtual_source_1, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
